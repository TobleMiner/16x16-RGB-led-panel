File: leds.sch (KiCad schematic (older format))
At the start: 64 parts

Commit message: DFM
Parts:
- added H? (x2): ToolingHole, ToolingHole:ToolingHole_JLCSMT, symbol Mechanical:MountingHole
